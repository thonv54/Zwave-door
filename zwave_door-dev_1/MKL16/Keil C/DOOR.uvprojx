# Keil uVision project DOOR.uvprojx, settings and files
target DOOR Sensor (ARM-ADS)
  device: MKL16Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.11.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFC00,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DOOR +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c misc: --asm
  c include: ..\App;..\Mid;..\Mid\serial;..\Com;..\Drivers;..\Drivers\periph
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group App
    ../App/: configapp.h configboard.h main.c keyconfig.c keyconfig.h
  group Serial
    ../Mid/serial/: serial.c serial.h serial_cmd.h cmdcommon.c cmdcommon.h cmddoor.c cmddoor.h cmdmulti.c cmdmulti.h cmdnetw.c cmdnetw.h cmdkeyconfig.c cmdkeyconfig.h cmdtxstatus.c cmdtxstatus.h cmdtimewakup.c cmdtimewakup.h cmdtimesensrp.c cmdtimesensrp.h
  group Mid
    ../Mid/: battmnge.c battmnge.h eventman.c eventman.h keypad.c keypad.h led.c led.h powerapi.c powerapi.h pwrmanager.c pwrmanager.h sysregval.c sysregval.h timer.c timer.h sensdoor.c sensdoor.h zwstatus.c zwstatus.h zwnetstatus.c zwnetstatus.h
  group Com
    ../Com/: buff.c buff.h debug.c debug.h macro.h typedefs.h utilities.c utilities.h
  group PeriphDrivers
    ../Drivers/periph/: driver_common.c driver_common.h gpio.c gpio.h irq.c irq.h llwu.c llwu.h lptmr.c lptmr.h mcg.c mcg.h pincommon.c pincommon.h pinmap.c pinmap.h pit.c pit.h pmc.c pmc.h rcm.c rcm.h rtc.c rtc.h sim.c sim.h smc.c smc.h tpm.c tpm.h uart.c uart.h flash.c flash.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
